#include "DeckThemes.h"

namespace {
// name, bg, surface, surfaceHi, line, ink, muted, accent, accent2, warn, good,
// onAccent, keyFill, keyFillAlt
const DeckTheme kThemes[] = {
    {"Ops Teal",
     deckRgb(0x0B, 0x11, 0x1C), deckRgb(0x16, 0x20, 0x2F), deckRgb(0x1E, 0x2B, 0x3D),
     deckRgb(0x2A, 0x3A, 0x4F), deckRgb(0xEA, 0xF0, 0xF7), deckRgb(0x82, 0x96, 0xAC),
     deckRgb(0x16, 0xC2, 0xC9), deckRgb(0x16, 0xC2, 0xC9), deckRgb(0xF7, 0xB7, 0x33),
     deckRgb(0x35, 0xD0, 0x7F), deckRgb(0x0B, 0x11, 0x1C), deckRgb(0x1B, 0x27, 0x38),
     deckRgb(0x18, 0x24, 0x34)},

    {"Amber CRT",
     deckRgb(0x0A, 0x07, 0x00), deckRgb(0x1A, 0x12, 0x00), deckRgb(0x2A, 0x1E, 0x00),
     deckRgb(0x4A, 0x36, 0x08), deckRgb(0xFF, 0xC2, 0x4D), deckRgb(0xA9, 0x79, 0x1F),
     deckRgb(0xFF, 0x9F, 0x1A), deckRgb(0xFF, 0xC2, 0x4D), deckRgb(0xFF, 0x6A, 0x00),
     deckRgb(0xFF, 0xD2, 0x4D), deckRgb(0x0A, 0x07, 0x00), deckRgb(0x1A, 0x12, 0x00),
     deckRgb(0x14, 0x0E, 0x00)},

    {"Synthwave",
     deckRgb(0x16, 0x0D, 0x22), deckRgb(0x24, 0x16, 0x34), deckRgb(0x33, 0x1E, 0x4A),
     deckRgb(0x45, 0x2C, 0x63), deckRgb(0xF5, 0xE6, 0xFF), deckRgb(0xA9, 0x8A, 0xC9),
     deckRgb(0xFF, 0x3C, 0xAC), deckRgb(0x7A, 0x5C, 0xFF), deckRgb(0xFF, 0x8A, 0x3C),
     deckRgb(0x3C, 0xE0, 0xC0), deckRgb(0x16, 0x0D, 0x22), deckRgb(0x24, 0x16, 0x34),
     deckRgb(0x1D, 0x12, 0x30)},

    {"Matrix",
     deckRgb(0x02, 0x0A, 0x03), deckRgb(0x06, 0x18, 0x0A), deckRgb(0x0A, 0x24, 0x0E),
     deckRgb(0x12, 0x4A, 0x18), deckRgb(0x7C, 0xFF, 0x88), deckRgb(0x35, 0xA0, 0x47),
     deckRgb(0x35, 0xD0, 0x7F), deckRgb(0x7C, 0xFF, 0x88), deckRgb(0xC7, 0xFF, 0x33),
     deckRgb(0x35, 0xD0, 0x7F), deckRgb(0x02, 0x0A, 0x03), deckRgb(0x06, 0x18, 0x0A),
     deckRgb(0x04, 0x12, 0x07)},

    // Pastel (light): dark ink on soft light surfaces.
    {"Pastel",
     deckRgb(0xF3, 0xEF, 0xF7), deckRgb(0xFF, 0xFF, 0xFF), deckRgb(0xED, 0xE6, 0xF6),
     deckRgb(0xD8, 0xCE, 0xE8), deckRgb(0x4A, 0x3F, 0x5C), deckRgb(0x8B, 0x7F, 0xA3),
     deckRgb(0x7E, 0xC8, 0xB0), deckRgb(0xA7, 0x8B, 0xD0), deckRgb(0xF2, 0xB5, 0xA0),
     deckRgb(0x8F, 0xC9, 0x9A), deckRgb(0x2C, 0x24, 0x38), deckRgb(0xFF, 0xFF, 0xFF),
     deckRgb(0xF1, 0xEB, 0xFA)},

    // Cotton Candy (pastel): pink/blue on cream.
    {"Cotton Candy",
     deckRgb(0xFB, 0xEF, 0xF6), deckRgb(0xFF, 0xF5, 0xFB), deckRgb(0xFC, 0xE6, 0xF2),
     deckRgb(0xF3, 0xCB, 0xE0), deckRgb(0x5A, 0x46, 0x57), deckRgb(0xB0, 0x8A, 0xA0),
     deckRgb(0xFF, 0x8F, 0xBE), deckRgb(0x8F, 0xC6, 0xFF), deckRgb(0xFF, 0xBE, 0x8F),
     deckRgb(0x8F, 0xE0, 0xBE), deckRgb(0x4A, 0x2E, 0x3E), deckRgb(0xFF, 0xF5, 0xFB),
     deckRgb(0xFB, 0xEA, 0xF3)},
};

const uint8_t kThemeCount = sizeof(kThemes) / sizeof(kThemes[0]);
}  // namespace

uint8_t deckThemeCount() { return kThemeCount; }

const DeckTheme &deckTheme(uint8_t index) {
  if (index >= kThemeCount) index = 0;
  return kThemes[index];
}

int deckThemeIndexFromName(const String &name) {
  String want = name;
  want.trim();
  want.toLowerCase();
  if (want.length() == 0) return -1;
  for (uint8_t i = 0; i < kThemeCount; ++i) {
    String have = kThemes[i].name;
    have.toLowerCase();
    if (have.startsWith(want)) return i;
  }
  return -1;
}
