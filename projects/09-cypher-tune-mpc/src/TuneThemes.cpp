#include "TuneThemes.h"

namespace {
// name, bg, surface, surfaceHi, line, ink, muted, accent, accentDim,
// padFill, padFillAlt, padSel, padFlash, playhead, good, warn, danger, onAccent
const TuneTheme kThemes[] = {
    // Index 0 is the shared "ops" look the rest of the repo uses, so the panel
    // boots looking like its sibling projects.
    {"Ops Teal",
     tuneRgb(0x0B, 0x11, 0x1C), tuneRgb(0x16, 0x20, 0x2F), tuneRgb(0x1E, 0x2B, 0x3D),
     tuneRgb(0x2A, 0x3A, 0x4F), tuneRgb(0xEA, 0xF0, 0xF7), tuneRgb(0x82, 0x96, 0xAC),
     tuneRgb(0x16, 0xC2, 0xC9), tuneRgb(0x0C, 0x6E, 0x72),
     tuneRgb(0x16, 0x20, 0x2F), tuneRgb(0x19, 0x24, 0x35), tuneRgb(0x1E, 0x2B, 0x3D),
     tuneRgb(0x3D, 0xF0, 0xF7), tuneRgb(0x8A, 0xF7, 0xFA),
     tuneRgb(0x35, 0xD0, 0x7F), tuneRgb(0xF7, 0xB7, 0x33), tuneRgb(0xFF, 0x54, 0x70),
     tuneRgb(0x0B, 0x11, 0x1C)},

    // Akai MPC3000 bench vibe: charcoal chassis, grey rubber pads, gold hits.
    {"MPC Classic",
     tuneRgb(0x0E, 0x0E, 0x0F), tuneRgb(0x1C, 0x1C, 0x1E), tuneRgb(0x28, 0x28, 0x2B),
     tuneRgb(0x3A, 0x3A, 0x3E), tuneRgb(0xF2, 0xF0, 0xEA), tuneRgb(0x8E, 0x8C, 0x88),
     tuneRgb(0xE8, 0xB0, 0x3C), tuneRgb(0x6E, 0x52, 0x18),
     tuneRgb(0x2B, 0x2B, 0x2E), tuneRgb(0x25, 0x25, 0x28), tuneRgb(0x3A, 0x39, 0x35),
     tuneRgb(0xFF, 0xD1, 0x66), tuneRgb(0xFF, 0xE0, 0x9B),
     tuneRgb(0x6E, 0xC8, 0x7A), tuneRgb(0xE8, 0xB0, 0x3C), tuneRgb(0xE2, 0x4C, 0x3C),
     tuneRgb(0x0E, 0x0E, 0x0F)},

    // Roland TR-808 faceplate: cream chrome with the orange/red/yellow step run.
    {"TR-808",
     tuneRgb(0x12, 0x10, 0x0E), tuneRgb(0x24, 0x20, 0x1C), tuneRgb(0x33, 0x2C, 0x25),
     tuneRgb(0x4A, 0x40, 0x35), tuneRgb(0xF5, 0xEC, 0xDD), tuneRgb(0xA3, 0x94, 0x80),
     tuneRgb(0xFF, 0x6A, 0x1F), tuneRgb(0x7A, 0x2E, 0x0C),
     tuneRgb(0x2A, 0x25, 0x20), tuneRgb(0x24, 0x20, 0x1B), tuneRgb(0x3C, 0x33, 0x2A),
     tuneRgb(0xFF, 0xC4, 0x2E), tuneRgb(0xFF, 0xE0, 0x7A),
     tuneRgb(0xE8, 0xC7, 0x3A), tuneRgb(0xFF, 0x9F, 0x1A), tuneRgb(0xE0, 0x2B, 0x1E),
     tuneRgb(0x12, 0x10, 0x0E)},

    {"Synthwave",
     tuneRgb(0x16, 0x0D, 0x22), tuneRgb(0x24, 0x16, 0x34), tuneRgb(0x33, 0x1E, 0x4A),
     tuneRgb(0x45, 0x2C, 0x63), tuneRgb(0xF5, 0xE6, 0xFF), tuneRgb(0xA9, 0x8A, 0xC9),
     tuneRgb(0xFF, 0x3C, 0xAC), tuneRgb(0x7A, 0x1E, 0x5C),
     tuneRgb(0x27, 0x18, 0x39), tuneRgb(0x2C, 0x1B, 0x40), tuneRgb(0x3B, 0x23, 0x55),
     tuneRgb(0x3C, 0xE0, 0xC0), tuneRgb(0xFF, 0x8A, 0xD4),
     tuneRgb(0x3C, 0xE0, 0xC0), tuneRgb(0xFF, 0x8A, 0x3C), tuneRgb(0xFF, 0x3C, 0x6E),
     tuneRgb(0x16, 0x0D, 0x22)},

    {"Matrix",
     tuneRgb(0x02, 0x0A, 0x03), tuneRgb(0x06, 0x18, 0x0A), tuneRgb(0x0A, 0x24, 0x0E),
     tuneRgb(0x12, 0x4A, 0x18), tuneRgb(0x7C, 0xFF, 0x88), tuneRgb(0x35, 0xA0, 0x47),
     tuneRgb(0x35, 0xD0, 0x7F), tuneRgb(0x0E, 0x5A, 0x2A),
     tuneRgb(0x07, 0x1C, 0x0B), tuneRgb(0x05, 0x16, 0x09), tuneRgb(0x0C, 0x2C, 0x12),
     tuneRgb(0xC7, 0xFF, 0x33), tuneRgb(0xA8, 0xFF, 0xB4),
     tuneRgb(0x35, 0xD0, 0x7F), tuneRgb(0xC7, 0xFF, 0x33), tuneRgb(0xFF, 0x6A, 0x4A),
     tuneRgb(0x02, 0x0A, 0x03)},

    // Light theme: dark ink on soft surfaces, candy pads.
    {"Cotton Candy",
     tuneRgb(0xFB, 0xEF, 0xF6), tuneRgb(0xFF, 0xF5, 0xFB), tuneRgb(0xFC, 0xE6, 0xF2),
     tuneRgb(0xE8, 0xC6, 0xDC), tuneRgb(0x4A, 0x2E, 0x3E), tuneRgb(0xB0, 0x8A, 0xA0),
     tuneRgb(0xFF, 0x5F, 0xA2), tuneRgb(0xFF, 0xB8, 0xD6),
     tuneRgb(0xFF, 0xF5, 0xFB), tuneRgb(0xFC, 0xEC, 0xF5), tuneRgb(0xF6, 0xD9, 0xEA),
     tuneRgb(0x5F, 0xC6, 0xFF), tuneRgb(0xFF, 0x9F, 0xC8),
     tuneRgb(0x4F, 0xC0, 0x92), tuneRgb(0xFF, 0xA5, 0x3C), tuneRgb(0xF0, 0x4E, 0x6E),
     tuneRgb(0x3A, 0x22, 0x30)},
};

const uint8_t kThemeCount = sizeof(kThemes) / sizeof(kThemes[0]);
}  // namespace

uint8_t tuneThemeCount() { return kThemeCount; }

const TuneTheme &tuneTheme(uint8_t index) {
  if (index >= kThemeCount) index = 0;
  return kThemes[index];
}

int tuneThemeIndexFromName(const String &name) {
  String want = name;
  want.trim();
  want.toLowerCase();
  if (want.length() == 0) return -1;
  for (uint8_t i = 0; i < kThemeCount; ++i) {
    String have = kThemes[i].name;
    have.toLowerCase();
    if (have.startsWith(want)) return i;
  }
  return -1;
}
